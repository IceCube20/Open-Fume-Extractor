#include "OfeP4BleEccFix.h"
#include <tinycrypt/ecc.h>
#include <tinycrypt/ecc_dh.h>
#include <string.h>
#include <esp_random.h>

// Use the P4 RNG, not the C6/HCI callback before the NimBLE host is running.
// The stock IDF 5.5.5 P4 startup keeps the SAR entropy source enabled.
static int ofe_p4_tinycrypt_rng(uint8_t *dest, unsigned int size) {
    if (!dest) return 0;
    esp_fill_random(dest, size);
    return 1;
}

// Public known-answer fixtures, independently checked with OpenSSL. These are
// never passed to NimBLE as pairing keys. Actual keys use the P4 RNG above.
// Scalars derive from SHA256("OFE ECC A 8/9") mod (P-256 order - 1) + 1.
static const uint8_t test_private[2][32] = {
    {0xb7,0xf7,0xb0,0x91,0xbd,0x80,0x4b,0x6c,0x58,0xd4,0x10,0xc0,0xf9,0x7e,0x9f,0xe8,
     0x54,0x1c,0x08,0x69,0x0d,0x7f,0xe1,0x01,0x1a,0x6c,0xc8,0x44,0x2c,0xed,0x97,0x7d},
    {0x1d,0x1c,0x20,0x10,0x61,0x75,0x8d,0x3f,0x4a,0x24,0x3b,0xb2,0x63,0x99,0x72,0x4b,
     0x23,0x18,0xd0,0xf0,0x85,0x75,0xb6,0xd5,0x69,0xa6,0x6b,0xbf,0xd2,0x47,0x5f,0x16}
};
static const uint8_t test_public[2][64] = {
    {0x2a,0xb7,0x3c,0x4e,0x3d,0x07,0x09,0x31,0xbc,0x73,0x8e,0x63,0xf4,0x0c,0xfa,0x6e,
     0x52,0x23,0x1a,0xea,0x5b,0x26,0xde,0xf4,0x08,0x72,0x94,0x7c,0x77,0x54,0xa2,0xc6,
     0x78,0xf7,0x0d,0x55,0x30,0xfb,0x22,0xbf,0x51,0x77,0x6a,0x7b,0x2e,0x8a,0xd8,0xbd,
     0x36,0xa9,0xe7,0x9c,0xa6,0xab,0x67,0x62,0x1c,0x94,0xae,0x21,0x9b,0x44,0xb4,0x11},
    {0xbb,0x8e,0x0f,0xe3,0x83,0x3c,0x3f,0x08,0x4c,0x22,0x9a,0xc0,0x12,0xc7,0xec,0x93,
     0x4d,0xd9,0xc1,0xd3,0xc8,0xa0,0xcf,0xc9,0x0b,0x70,0x7a,0x95,0xac,0x71,0x3f,0x26,
     0x4e,0xe4,0xb6,0x3a,0x27,0x06,0x22,0x48,0x11,0xf4,0x5b,0x37,0x81,0x9d,0xc9,0x0d,
     0xf1,0x5b,0x01,0x85,0x15,0xc2,0x17,0x0a,0x08,0x39,0x13,0x98,0x4b,0xfc,0x21,0xf4}
};
static const uint8_t test_shared[32] = {
    0xa3,0xfd,0xf2,0xd8,0xaf,0x87,0x5a,0x8f,0x00,0x45,0xa9,0xa9,0x42,0xdf,0x4e,0x03,
    0x8a,0xef,0x3d,0x53,0x7d,0xd3,0x9a,0xea,0xbe,0xf6,0x81,0x7b,0xe0,0x05,0xee,0x64
};

int ofe_p4_ble_ecc_self_test(void) {
    // nimble_port_init() installs an HCI RNG; replace it on every pairing start
    // and retain the P4 hardware RNG for subsequent Secure Connections keys.
    uECC_set_rng(ofe_p4_tinycrypt_rng);
    uint8_t point[64], secret[32];
    uECC_Curve curve = uECC_secp256r1();
    for (unsigned i = 0; i < 2; ++i) {
        const int base = -1010 - (int)i * 10;
        if (!uECC_compute_public_key(test_private[i], point, curve)) return base - 1;
        if (memcmp(point, test_public[i], sizeof(point))) return base - 2;
        if (uECC_valid_public_key(test_public[1-i], curve)) return base - 3;
        if (!uECC_shared_secret(test_public[1-i], test_private[i], secret, curve)) return base - 4;
        if (memcmp(secret, test_shared, sizeof(secret))) return base - 5;
    }
    return 0;
}
